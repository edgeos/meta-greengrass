KERNEL_ARGS_append = " cgroup_memory=1 cgroup_enable=memory "
